options:
  parameters:
    author: G4_E1C
    generate_options: qt_gui
    id: Practica1A
    output_language: python
    title: Uso de GNUradio
  states: {}

blocks:
- name: amplitud
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:1,0
    label: Amp
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: f_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:2,0
    label: Offset
    start: '0'
    step: '0.1'
    stop: 1e3
    value: '0'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:2,0
    label: FrqHz
    start: '0'
    step: '100'
    stop: 10e3
    value: 1e3
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:1,0
    label: Noise
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:1,1
    label: Offset
    start: '-5'
    step: '100e-3'
    stop: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label: WaveForm
    labels: '["Constant","Sine","Cosine","Square","Triangle","Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: raw
    value: '102'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitud
    freq: frequency
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: waveform
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: f_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tab_channel
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,2,3,1
    label0: Channel Controls
    num_tabs: '1'
  states: {}
- name: tab_source
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,2
    label0: Source Controls
    num_tabs: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
