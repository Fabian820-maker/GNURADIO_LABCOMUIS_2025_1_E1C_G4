options:
  parameters:
    author: EC1_G4
    category: '[ModulosE1C_G4]'
    copyright: UIS
    generate_options: hb
    id: ModulacionPAM
    output_language: python
    title: Generador de Pulsos
  states: {}

blocks:
- name: D
  id: parameter
  parameters:
    label: Ancho de pulso
    type: intx
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 50-D
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: fs
  id: parameter
  parameters:
    label: Frecuencia pulsos
    type: eng_float
    value: '1000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: pulsos
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Frecuencia muestreo
    type: eng_float
    value: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
