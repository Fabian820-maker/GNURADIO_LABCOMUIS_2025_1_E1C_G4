options:
  parameters:
    author: Nohelia
    copyright: UIS
    generate_options: qt_gui
    id: Practica4FMRX
    output_language: python
    title: Practica emisoras FM
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia RX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia RX [MHz]
    start: '88'
    step: '1E-2'
    stop: '108'
    value: '103.7'
  states: {}
- name: fcb
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de corte [kHz]
    start: '10'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/4
  states: {}
- name: Medidas
  id: qtgui_tab_widget
  parameters:
    label0: RX
    label1: Filtrada
    label2: Demodulada
    num_tabs: '3'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate/D
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/D
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_rate)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcb*1e3
    decim: int(D)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc*1e6
    fftsize: '8192'
    gui_hint: Medidas@0
    name: '"Señal RX"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: fc*1e6
    fftsize: '8192'
    gui_hint: Medidas@1
    name: '"Señal Filtrada"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: fc
    fftsize: '8192'
    gui_hint: Medidas@2
    name: '"Señal demodulada"'
    nconnections: '2'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/D)
    interp: int(audio_rate)
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc*1e6
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_0_1, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
