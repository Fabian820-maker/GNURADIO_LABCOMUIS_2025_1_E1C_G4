options:
  parameters:
    author: com1_E1C_G4
    generate_options: qt_gui
    id: ModulacionAManalisis
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: '# muestras/simbolo'
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {state: disabled}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '12'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la portadora [MHz]
    start: '50'
    step: '1'
    stop: 2.2e3
    value: '150'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '0'
    step: '1'
    stop: samp_rate/10
    value: 1e3
  states: {}
- name: n
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/16
  states: {}
- name: ModuladorAM_0
  id: ModuladorAM
  parameters:
    Ac: Ac
    Ka: Ka
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: int(math.pow(2,n))
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: (-math.pow(2,n)+1)/2
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/(math.pow(2,n)-1)
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(B)
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: m_t
  states: {}

connections:
- [ModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_random_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAM_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_repeat_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', ModuladorAM_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
