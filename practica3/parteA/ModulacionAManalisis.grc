options:
  parameters:
    author: com1_E1C_G4
    generate_options: qt_gui
    id: ModulacionAManalisis
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '12'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la portadora [MHz]
    start: '50'
    step: '1'
    stop: 2.2e3
    value: '150'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '0'
    step: '1'
    stop: samp_rate/10
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/16
  states: {}
- name: ModuladorAM_0
  id: ModuladorAM
  parameters:
    Ac: Ac
    Ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAM_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
